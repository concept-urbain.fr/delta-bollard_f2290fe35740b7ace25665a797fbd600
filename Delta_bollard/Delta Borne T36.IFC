Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Delta Borne T36.IFC
Time: 2020-07-01T13:08:13
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: DELT-BOR-T36-003_Default
In: Default Storey
Material: Fonte acier
PSet_Mass_Property - Mass Measure: 29.9634; Area Measure: 0.594605; Volume Measure: 0.00416158
