Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Delta Borne T68.IFC
Time: 2020-07-01T13:09:00
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: Delta Borne T68
In: Default Storey
Material: Fonte acier
PSet_Mass_Property - Mass Measure: 17.0993; Area Measure: 0.864979; Volume Measure: 0.00237491
