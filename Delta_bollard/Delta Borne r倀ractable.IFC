Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Delta Borne rétractableIFC.IFC
Time: 2020-07-01T13:10:01
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: DELT-BOR-RET-004-B_Default (2)
In: Default Storey
Material: AISI 304

# IfcBeam: DELT-BOR-RET-014_Default
In: Default Storey
Material: AISI 304

# IfcBuildingElementProxy: DELT-BOR-RET-003_Default
In: Default Storey
Material: Fonte ductile

# IfcBuildingElementProxy: DELT-BOR-RET-008-01_Default
In: Default Storey
PSet_Mass_Property - Mass Measure: 74.7737; Area Measure: 3.60886; Volume Measure: 0.00960555

# IfcBuildingElementProxy: DELT-BOR-RET-013_Default
In: Default Storey
Material: AISI 304
