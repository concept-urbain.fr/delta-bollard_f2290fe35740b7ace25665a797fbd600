Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Delta Borne T95.IFC
Time: 2020-07-01T13:09:17
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: Delta Borne T95
In: Default Storey
Material: FGS 400-15
PSet_Mass_Property - Mass Measure: 22.3001; Area Measure: 1.1586; Volume Measure: 0.0031189
